Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_5/temp/tmp_1820_0_ce9tG/format_0/424-1.ifc
Time: 2023-02-13T10:42:20
Made in: PARTsolutions

# IfcProject, 424-1
Description: Duschplan

# IfcDiscreteAccessory, 424-1
In: BUILDING
Description: 424-1
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 424-1
ePset_PARTsolutions - NB: 424-1; NN: Duschplan; NT: Duschplan; NBSYN: $PRODID.; LINA: 424-1; CATALOG: Kaldewei; PRODID: 424-1; DESCRIPTION_SHORT: There are days when you need a lot of space for yourself. And there are days when you want to have a lot of fun for two. Both are possible with the Duschplan Xxl. This is because of its extraordinary size, it gives freedom of movement when showering a completely new dimension.; DESCRIPTION_LONG: The classic shower for two; EDGE_WIDTH_E5: 65.0; OUTER_LENGTH_A1: 700.0; OUTLETPOSITION: cornerdrain; INNER_LENGTH_A5: 570.0; OUTER_FORM_DW: quadrangular; OUTER_RADIUS_R1: 12.0; INNER_WIDTH_B5: 1570.0; DISTANCE_BATHEDGE_TO_MID_DRAINHOLE_F2: 200.0; DEPTH_INNER_C1: 65.0; EDGE_HEIGHT_C4: 32.0; DIAMETER_DRAINHOLE_F9: 90.0; OUTER_WIDTH_B1: 1700.0; EF000010: Universal; EF000051: Rectangular; EF020814: false; EF025058: false; EF020363: false; EF002169: -; EF000386: 2,9; EF020621: 12,0; EF001438: 700,0; EF000008: 1700,0; EF000040: 32,0; EF001131: 65,0; EF022185: false; EF025073: false; EF025060: false; EF025074: -; EF000007: Beige; EF024897: Glossy; EF025075: false; EF020710: 90,0; EF025068: true; EF025076: false; EF023789: true; EF000139: Enamelled
